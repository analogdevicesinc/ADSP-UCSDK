inherit sc5xx-ucsdk